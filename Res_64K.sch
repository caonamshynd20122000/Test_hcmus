** sch_path: Res_64K.sch
**.subckt Res_64K R RR VSS
*.iopin R
*.iopin RR
*.ipin VSS
x1 VSS net1 RR Res_32K
x2 VSS R net1 Res_32K
**.ends
.end
