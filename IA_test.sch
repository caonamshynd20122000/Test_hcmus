v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/sky130_hcmus_ip__instramp/xschem/IA.sym} 460 -230 0 0 {name=x1}
